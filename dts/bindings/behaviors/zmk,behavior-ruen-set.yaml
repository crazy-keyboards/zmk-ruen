## dts/bindings/behaviors/zmk,behavior-ruen-set.yaml
```yaml
description: RuEn lang set behavior

compatible: "zmk,behavior-ruen-set"

include: one_param.yaml
```
